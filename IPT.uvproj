# Keil uVision project IPT.uvproj, settings and files
target 8051Kit (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: IPT +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: STARTUP.A51 Main.c IPTConfig.c 8051Lib.C 8051Lib_I.ASM Error.c LongMult.asm
